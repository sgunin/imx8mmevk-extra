do_install_append() {
	rm -f ${D}${includedir}/gphoto2/gphoto2
}
